<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ieee802154_transceiver</value></param>
<param><key>author</key><value>Dimitrios-Georgios Akestoridis</value></param>
<param><key>description</key><value>A simplified version of Bastian Bloessl's GRC flow graph for an IEEE 802.15.4 transceiver.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>IEEE 802.15.4 Transceiver</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>channel</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>label</key><value>Channel Number</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2405000000 + 5000000*(channel - 11)</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>freq_label</value></param>
<param><key>value</key><value>freq / 1000000000.0</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
<param><key>label</key><value>Frequency (GHz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>page_label</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label</key><value>Channel Page</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/ieee802154.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>195</value></param>
</block>
<block>
<key>ieee802_15_4_oqpsk_phy</key>
<param><key>id</key><value>ieee802_15_4_oqpsk_phy_0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>1</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>pdu_length</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>1</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>pdus</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>rxout</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
